IMAGE_BOOT_FILES:append = " overlays/dht11.dtbo"